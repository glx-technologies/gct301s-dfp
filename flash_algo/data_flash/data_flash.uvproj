# Keil uVision project data_flash.uvproj, settings and files
target GCT301S_Data_Flash (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: GCT301S_Data_Flash
  AfterMake: cmd.exe /C copy "%L" "..\..\Files\Flash\@L.FLM"
  c flags: Optim=3
  c define: DATA_FLASH
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ../src/: FlashDev.c FlashPrg.c
